# Keil uVision project rbc_mesh_BLE_Gateway.uvprojx, settings and files
target nRF51422 xxAC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rbc_mesh_example_master +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT DEBUG RBC_MESH_DEBUG PACKET_STATS
  c misc: --c99
  c include: ..\include;..\..\..\RTT;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\softdevices\s110_nrf51_8.0.0\s110_nrf51_8.0.0_API\include
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group app
    ../: main.c nrf_adv_conn.c led_config.c
  group rbc_mesh
    ../../../rbc_mesh/src/: rbc_mesh.c nrf_flash.c mesh_flash.c radio_control.c timer.c timeslot.c trickle.c mesh_gatt.c transport_control.c mesh_aci.c serial_handler_uart.c fifo.c event_handler.c version_handler.c mesh_packet.c bootloader_util.c rand.c handle_storage.c timer_scheduler.c dfu_app.c
  group core
    ./: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
    ../../../../../../components/ble/common/: ble_advdata.c
    ../../../../../../components/drivers_nrf/spi_slave/: spi_slave.c
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
target nRF51422 xxAC_with_ack_master (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rbc_mesh_example_with_ack_master +hex
  c flags: Optim=1 wLevel=2
  c define: WITH_ACK_MASTER BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT DEBUG RBC_MESH_DEBUG PACKET_STATS
  c misc: --c99
  c include: ..\include;..\..\..\RTT;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\device
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x6000
target nRF51422 xxAC_with_ack_slave (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rbc_mesh_example_with_ack_slave +hex
  c flags: Optim=1 wLevel=2
  c define: WITH_ACK_SLAVE BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT DEBUG RBC_MESH_DEBUG PACKET_STATS
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x6000
target nRF51422 xxAC_without_ack_master (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rbc_mesh_example_without_ack_master +hex
  c flags: Optim=1 wLevel=2
  c define: WITHOUT_ACK_MASTER BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT DEBUG RBC_MESH_DEBUG PACKET_STATS
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x6000
target nRF51422 xxAC_without_ack_slave (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: rbc_mesh_example_without_ack_slave +hex
  c flags: Optim=1 wLevel=2
  c define: WITHOUT_ACK_SLAVE BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT DEBUG RBC_MESH_DEBUG PACKET_STATS
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x6000
